# Keil uVision project modemDragonfly.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB452REQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.5
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: modemDragonfly +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\modemDragonfly.axf --output modemDragonfly.bin
  AfterMake: .\__Get_OTA_Info.exe
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,N32WB452_BT_API,BD_RTC_USE_LSI,BLE_OTA_WRITE_CHAR_EN,__STDC_LIMIT_MACROS,__STDC_CONSTANT_MACROS,__STRICT_ANSI__
  c misc: --wchar32 --cpp
  c include: ..\.\Library\Bluetooth;..\.\Library\Can;..\.\Library\Core;..\.\Library\Gsm;..\.\Library\Led;..\.\Library\Panel;..\.\Library\Usart;.\User;..\.\Library\Ble;..\.\Library;..\Library\Json;..\.\Library\Timers;..\.\Library\Story;..\.\Library\Heater;..\Library\Graph;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32wb452_std_periph_driver\inc;..\firmware\n32wb452_ble_driver\inc;..\firmware\n32wb452_ble_driver\btapi\inc;..\firmware\n32wb452_ble_driver\profile\inc;..\firmware\n32wb452_ble_driver\platform\inc;..\firmware\n32wb452_ble_driver;.\User\bsp;.\User\ota;.\User\ota\crc16;.\User\ota\encrypt;.\User\ota\sha1;.\User\api\inc;..\Library\Temperature;..\Library\Button;..\Library\Randomize;..\Library\Gprs;..\Library\Sms;..\Library\Out;..\Library\Usb\inc;..\firmware\n32wb452_usbfs_driver\inc;..\Library\Flash;..\Library\Gpio;..\Library\Bridge;..\Library\Sms
  memory RVCT4: ROM 0x8030000 size 0x4f800
  memory RVCT9: RAM 0x20000000 size 0x23f00
  group Main
    ./User/: DataActualizator.cpp main.cpp work.cpp Version.h
    ../Library/Core/: log.c
    ../Library/Timers/: unix_time.cpp
  group Modem
    ./User/: Modem.cpp modem_handler.cpp
  group Timberline
    ./User/: FaultManager.cpp Timberline.cpp
    ../Library/Sms/: timberline_sms.cpp
  group Heaters
    ./User/: Heaters.cpp
  group Drivers
    ./User/: StringTransfer.cpp n32wb452_it.c SlcanBridge.cpp
    .././Library/Led/: led.cpp
    .././Library/Core/: core.cpp
    ../Library/Button/: button.cpp
    ../Library/Randomize/: randomize.cpp
    ./User/bsp/: bsp_spi.c
    ../Library/Flash/: flash.cpp
    .././Library/Usart/: usart.cpp
    .././Library/Can/: can.cpp
    ../Library/Gpio/: gpio.h
  group USB
    ../Library/Usb/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group n32wb452_usbfs_driver
    ../firmware/n32wb452_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Startup
    ../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32wb452.c
  group Library
    ../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_can.c n32wb452_crc.c n32wb452_dac.c n32wb452_dbg.c n32wb452_dma.c n32wb452_dvp.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_iwdg.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_sdio.c n32wb452_spi.c n32wb452_tim.c n32wb452_tsc.c n32wb452_usart.c n32wb452_wwdg.c
